# Keil uVision project UCOSII-1.uvprojx, settings and files
target UCOSII-1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: UCOSII-1 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\UCOSII\CONFIG;..\UCOSII\CORE;..\UCOSII\PORT;..\HARDWARE\LED;..\HARDWARE\LCD;..\HARDWARE\RTC;..\HARDWARE\KEY;..\HARDWARE\TIMER;..\HARDWARE\BEEP
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/BEEP/: beep.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_dbgmcu.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_bkp.c stm32f10x_fsmc.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_tim.c
  group UCOSII-CORE
    ../UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOSII-PORT
    ../UCOSII/PORT/: os_cpu_a.asm os_cpu_c.c os_cpu.h
  group UCOSII-CONFIG
    ../UCOSII/CONFIG/: includes.h os_cfg.h
  group README
    ../: README.TXT
